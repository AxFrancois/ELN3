# Keil uVision project Proj_ELN3.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Sim_Proj_ELN3
  c flags: Optimize=8 SizeSpeed=1
  group Programmes Source 1
    ./: Main_Proj_ELN3.asm Lib_Proj_ELN3.asm Lib_Proj_ELN3_Hidden.OBJ Base_SP.asm Lib_VosSP_PINCEMIN.asm Lib_VosSP_FRANCOIS.asm Lib_VosSP_LE_CORRE.asm Lib_VosSP_TCHIKLADZE.asm
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: EXE_SM4
  c flags: Optimize=8 SizeSpeed=1
