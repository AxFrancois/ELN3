# Keil uVision project Projet_TP3.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP3_EXO
  c flags: Optimize=8 SizeSpeed=1
  group Programmes source 1
    ./: EXO_TP3.asm
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: SM1_Exo
  c flags: Optimize=8 SizeSpeed=1
