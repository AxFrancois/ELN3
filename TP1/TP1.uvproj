# Keil uVision project TP1.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: TP1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Demo_TP_SM1.asm Demo_TP_SM1_V2.asm EXO1_SM1.asm
